## base_external/package/ldd3/Config.in
```kconfig
config BR2_PACKAGE_LDD3
	bool "ldd3"
	depends on BR2_LINUX_KERNEL
	help
		misc-modules and scull
```
